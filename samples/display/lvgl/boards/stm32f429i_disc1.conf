## samples/display/lvgl/boards/stm32f429i_disc1.conf
```kconfig
CONFIG_LVGL=y
CONFIG_LVGL_HOR_RES_MAX=320
CONFIG_LVGL_VER_RES_MAX=240
CONFIG_LVGL_DPI=100
```
